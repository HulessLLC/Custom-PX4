## src/drivers/custom_battery/Kconfig
```kconfig
menuconfig DRIVERS_CUSTOM_BATTERY
	bool "custom_battery"
	default n
	---help---
		Enable support for custom battery
```
